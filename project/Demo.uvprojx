# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  AfterMake: C:\xiazai\keil_5\ARM\ARMCC\bin\fromelf.exe --bin -o .\Objects\Demo.bin .\Objects\Demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user\API;..\user;..\STM32F10x_StdPeriph_Driver\inc;..\mqtt;..\freertos\include;..\freertos\port\RVDS\ARM_CM3;..\lvgl;..\lvgl\porting;..\lvgl\src;..\lvgl\src\lv_core;..\lvgl\src\lv_draw;..\lvgl\src\lv_font;..\lvgl\src\lv_hal;..\lvgl\src\lv_misc;..\lvgl\src\lv_themes;..\lvgl\src\lv_widgets;..\lvgl\app;..\lvgl\generated;..\lvgl\generated\guider_customer_fonts;..\lvgl\generated\guider_fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group user
    ../user/: stm32f10x_it.c system_stm32f10x.c main.c FreeRTOSConfig.h
  group api
    ../user/API/: led.c delay.c key.c relay.c ele_machine.c exti.c tim6.c tim7.c uart1.c kqm.c su03t.c dht.c pwm.c soft_iic.c bh1750.c hard_iic.c spi.c w25q64.c adc.c dma.c rtc.c lcd.c esp.c mqtt.c Fontdownload.c iwdg.c
  group stdlib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group mqtt
    ../mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group freertos/src
    ../freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/port
    ../freertos/port/MemMang/: heap_4.c
    ../freertos/port/RVDS/ARM_CM3/: port.c
  group lvgl/app
    ../lvgl/app/: lvgl_app.c shidu.c wendu.c wd.c w25q_lvgl_img.c Myfont_24.c BG.c
    ../lvgl/generated/guider_fonts/: Myfont_hyq24.c
  group lvgl/porting
    ../lvgl/porting/: lv_port_disp.c
    ../lvgl/: lv_conf.h
  group lvgl/src
    ../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lvgl/gui
    ../lvgl/generated/: events_init.c gui_guider.c setup_scr_screen_1.c
    ../lvgl/generated/images/: _123_alpha_102x100.c _2206D4B2C6E98322AC44AF223FAEC7A1_alpha_102x100.c _213242C09CA4EE3A5E54359E297D2991_alpha_35x35.c _213242C09CA4EE3A5E54359E297D2991_alpha_102x100.c _co2_alpha_20x20.c _dianchi_alpha_20x20.c _e8d2dd8e0735bd878fc9d4f667d556d7_alpha_320x240.c _lanya_alpha_20x20.c _ledoff_alpha_20x20.c _ledon_alpha_20x20.c _light_alpha_20x20.c _noWIFI_alpha_20x20.c _rainsmall_alpha_35x35.c _shidu_alpha_20x20.c _shijian_alpha_20x20.c _sun_alpha_35x35.c _wendu_alpha_20x20.c _WIFI_alpha_20x20.c _yun_alpha_35x35.c
    ../lvgl/generated/guider_fonts/: lv_font_hanyiqingzhouxing_16.c lv_font_hanyiqingzhouxing_24.c
software components: CMSIS:CORE 5.2.0
